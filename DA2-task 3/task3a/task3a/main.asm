.INCLUDE "M328DEF.INC"
	LDI R16,0xFF
	SBI DDRB,2 
	LDI R17,0
	OUT PORTB,R17
	LDI R18, 0xff
BEGIN: 
	LDI R20, 0xff
	OUT OCR0A,R20 
	LDI R20,(1<<WGM01)
	OUT TCCR0A,R20 
	LDI R20,5;
	OUT TCCR0B, R20
AGAIN: 
	IN R20,TIFR0 
	SBRS R20,1 
	RJMP AGAIN
	DEC R18
	SBRS R18,0
	RJMP BEGIN
	LDI R20,0x0
	OUT TCCR0B,R20 
	LDI R20,(1<<OCF0A)
	OUT TIFR0,R20 
	EOR R17,R16 
	OUT PORTB,R17 
	LDI R18,0xff
	RJMP BEGIN